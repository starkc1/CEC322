# Keil uVision project lab10_prob.uvprojx, settings and files
target prob (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: target_sim
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  group Soruce for prob
    ./source/: lab10_main_prob.c lab10_c_functions.c lab10_asm_functions_prob.s
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1, Compiler:I/O:STDOUT 1.2.0
